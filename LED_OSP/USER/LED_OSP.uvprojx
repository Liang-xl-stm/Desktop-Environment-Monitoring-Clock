# Keil uVision project LED_OSP.uvprojx, settings and files
target LED_OSP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED_OSP +hex
  AfterMake: "C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe" --bin --output "..\OBJ\LED_OSP.bin" "#L"
  AfterMake: python "..\Tools\add_openblt_checksum.py" "..\OBJ\LED_OSP.bin"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\USER;..\Application;..\Application\Firmware;..\Application\Picture;..\Hardware\EPD_4in26;..\Hardware\LED;..\Hardware\SPI;..\Hardware\W25Q128;..\Hardware\ESP8266;..\SYSTEM\usart;..\SYSTEM\log;..\CORE\CMSIS\Include;..\CORE\CMSIS\Device\ST\STM32F4xx\Include;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middlewares\lwesp\src\include;..\Middlewares\lwesp\src\include\system\port\freertos;..\Middlewares\EasyLogger\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c freertos_hooks.c system_stm32f4xx.c stm32f4xx_conf.h FreeRTOSConfig.h app_config.h lwesp_opts.h elog_cfg.h firmware_tcp_config.h w25q128_config.h epd_config.h
  group Application
    ../Application/Firmware/: firmware_tcp.c firmware_stream.c firmware_startup.c firmware_update.c
    ../Application/: w25q128_test.c app.c esp_app.c epd_app.c epd_app.h download_stream.c download_stream.h
  group SYSTEM/log
    ../SYSTEM/log/: log.c elog_port.c log.h
  group Hardware/W25Q128
    ../Hardware/W25Q128/: w25q128.c w25q128.h
  group Hardware/SPI
    ../Hardware/SPI/: spi.c spi.h
  group Hardware/LED
    ../Hardware/LED/: led.c led.h
  group SYSTEM/usart
    ../SYSTEM/usart/: usart.c usart.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_flash_ramfunc.c
  group EasyLogger
    ../Middlewares/EasyLogger/src/: elog.c elog_utils.c
  group FreeRTOS
    ../FreeRTOS/: tasks.c list.c queue.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group CORE
    ../CORE/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group lwesp
    ../Middlewares/lwesp/src/lwesp/: lwesp.c lwesp_ap.c lwesp_ble.c lwesp_bt.c lwesp_buff.c lwesp_conn.c lwesp_debug.c lwesp_dhcp.c lwesp_dns.c lwesp_evt.c lwesp_flash.c lwesp_hostname.c lwesp_input.c lwesp_int.c lwesp_mdns.c lwesp_mem.c lwesp_parser.c lwesp_pbuf.c lwesp_ping.c lwesp_server.c lwesp_smart.c lwesp_sntp.c lwesp_sta.c lwesp_threads.c lwesp_timeout.c lwesp_unicode.c lwesp_utils.c lwesp_webserver.c lwesp_wps.c
    ../Middlewares/lwesp/src/system/: lwesp_sys_freertos.c
  group Hardware/ESP8266
    ../Hardware/ESP8266/: lwesp_ll_stm32f407.c
  group Hardware/EPD_4in26
    ../Hardware/EPD_4in26/: DEV_Config.c DEV_Config.h EPD_4in26.c EPD_4in26.h
  group Application/Picture
    ../Application/Picture/: picture_store.c picture_store.h
